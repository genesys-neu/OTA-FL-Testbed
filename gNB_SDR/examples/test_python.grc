options:
  parameters:
    generate_options: qt_gui
    id: test_python
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: OTA_FL_addSubSelect_0
  id: OTA_FL_addSubSelect
  parameters:
    selector: 'True'
  states: {state: disabled}
- name: OTA_FL_dynamic_padder_py_0
  id: OTA_FL_dynamic_padder_py
  parameters:
    imag: '0.0'
    real: '0.0'
  states: {}
- name: OTA_FL_read_gold_seq_0
  id: OTA_FL_read_gold_seq
  parameters:
    file_path: '''/home/otatestbed/Suyash_OTA_FL/gr-beamforming/examples/data/trainingSig1'''
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '50'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_EXPONENTIAL
    mean: '1000'
    msg: pmt.intern("TEST")
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [OTA_FL_addSubSelect_0, '0', blocks_throttle2_0, '0']
- [OTA_FL_dynamic_padder_py_0, '0', qtgui_time_sink_x_0, '0']
- [OTA_FL_dynamic_padder_py_0, '0', uhd_usrp_sink_0, '0']
- [OTA_FL_read_gold_seq_0, '0', OTA_FL_dynamic_padder_py_0, '0']
- [analog_const_source_x_0, '0', OTA_FL_addSubSelect_0, '1']
- [analog_sig_source_x_0, '0', OTA_FL_addSubSelect_0, '0']
- [blocks_message_strobe_0, strobe, OTA_FL_dynamic_padder_py_0, trigger]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
