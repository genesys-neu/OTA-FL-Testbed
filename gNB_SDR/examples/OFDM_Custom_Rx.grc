options:
  parameters:
    generate_options: qt_gui
    id: OFDM_Custom_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: OTA_FL_correlate_and_tag_py_0
  id: OTA_FL_correlate_and_tag_py
  parameters:
    cor_method: '0'
    feedback_type: '0'
    file_path: '"/home/ssp2943/Documents/gNB SDR/Suyash_OTA_FL/gr-OTA_FL/data/trainingSig"'
    frame_len: 16456 + 500 + 38400 + 256
    num_Tx: '1'
    seq_len: '16456'
  states: {}
- name: OTA_FL_filter_payload_py_0
  id: OTA_FL_filter_payload_py
  parameters:
    tag_name: '"payload"'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ssp2943/Documents/OTA-FL-Demo/CSI-Use-Case/payload.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0625'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'True'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: IQ
    name: XCor
    size: '200000'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 1e6
    center_freq0: 900e6
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"addr=192.168.70.2"'
    dev_args: '""'
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [OTA_FL_correlate_and_tag_py_0, '0', OTA_FL_filter_payload_py_0, '0']
- [OTA_FL_correlate_and_tag_py_0, '1', blocks_complex_to_mag_0, '0']
- [OTA_FL_filter_payload_py_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_1_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', OTA_FL_correlate_and_tag_py_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
