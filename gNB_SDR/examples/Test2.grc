options:
  parameters:
    generate_options: qt_gui
    id: Test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/genesys/Demo/data.bin
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/genesys/Demo/test.bin
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'True'
    shift: 'False'
    type: complex
    window: ()
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 900e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 1e6
    center_freq0: 900e6
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: '"addr=192.168.70.2"'
    dev_args: '""'
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
