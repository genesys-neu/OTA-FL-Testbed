options:
  parameters:
    generate_options: no_gui
    id: OFDM_multi_db
    output_language: python
  states: {}

blocks:
- name: NFFT
  id: variable
  parameters:
    value: '32'
  states: {}
- name: N_edge_zeros
  id: variable
  parameters:
    value: '4'
  states: {}
- name: numTxAntennas
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_active_mod
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: subcarrier_size
  id: variable
  parameters:
    value: '1'
  states: {}
- name: trainingSignal_size
  id: variable
  parameters:
    value: '16456'
  states: {}
- name: tx_id_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_id_1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: OTA_FL_Precoder_0
  id: OTA_FL_Precoder
  parameters:
    Tx_ID: '0'
    file_path: ''
    multicast_IP: 224.3.28.70
    multicast_port: '10000'
    number_of_tx_antennas: '1'
  states: {}
- name: OTA_FL_Precoder_0_0
  id: OTA_FL_Precoder
  parameters:
    Tx_ID: '0'
    file_path: ''
    multicast_IP: 224.3.28.70
    multicast_port: '10000'
    number_of_tx_antennas: '1'
  states: {state: disabled}
- name: OTA_FL_dynamic_padder_0
  id: OTA_FL_dynamic_padder
  parameters:
    imag: '0.0'
    real: '0.0'
  states: {state: disabled}
- name: OTA_FL_dynamic_padder_py_0
  id: OTA_FL_dynamic_padder_py
  parameters:
    imag: '0'
    real: '0'
  states: {state: disabled}
- name: OTA_FL_read_gold_seq_0
  id: OTA_FL_read_gold_seq
  parameters:
    file_path: '"/root/Suyash_OTA_FL/gr-OTA_FL/data/trainingSig1"'
  states: {}
- name: OTA_FL_read_gold_seq_0_0
  id: OTA_FL_read_gold_seq
  parameters:
    file_path: '"/root/Suyash_OTA_FL/gr-OTA_FL/data/trainingSig1"'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/Suyash_OTA_FL/gr-OTA_FL/data/Ones.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/genesys/Demo/Suyash_OTA_FL/gr-OTA_FL/data/QPSK.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/genesys/Demo/Suyash_OTA_FL/gr-OTA_FL/data/QPSK.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      This module triggers the event 
        to generate payload
        to read file for CSI information
    msg: pmt.PMT_T
    period: '50'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      This module triggers the event 
        to generate payload
        to read file for CSI information
    msg: pmt.PMT_T
    period: '50'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.17'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.17'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.17'
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_0_1
  id: blocks_repeat
  parameters:
    interp: 400 * numTxAntennas
    type: complex
  states: {}
- name: blocks_repeat_0_0_0_1_0
  id: blocks_repeat
  parameters:
    interp: 100* numTxAntennas
    type: complex
  states: {}
- name: blocks_repeat_0_0_0_1_0_0
  id: blocks_repeat
  parameters:
    interp: 100* numTxAntennas
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_0_1_1
  id: blocks_repeat
  parameters:
    interp: 400 * numTxAntennas
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (trainingSignal_size, 400, 32, 256 * 103, 100)
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_stream_mux_1_0
  id: blocks_stream_mux
  parameters:
    lengths: (trainingSignal_size, 400, 32, 256 * 103, 100)
    num_inputs: '5'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: NFFT
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: NFFT
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: NFFT
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'False'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'False'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'False'
    shift: 'False'
    type: complex
    window: ()
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 480e3
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: Tx Signal 1 Time Sync
    size: '256'
    srate: '32000'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: 3840e3
    bw1: 3840e3
    center_freq0: 900e6
    center_freq1: 900e6
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '31.5'
    gain1: '10'
    len_tag_name: ''
    nchan: '2'
    samp_rate: 3840e3
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DMRS
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: payload2
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: DMRS
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload2
  states: {state: disabled}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: DMRS
  states: {state: disabled}
- name: zero_padding_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: zero_padding_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}

connections:
- [OTA_FL_Precoder_0, '0', fft_vxx_0_0, '0']
- [OTA_FL_Precoder_0_0, '0', fft_vxx_0_0_0, '0']
- [OTA_FL_dynamic_padder_0, '0', uhd_usrp_sink_0, '0']
- [OTA_FL_dynamic_padder_py_0, '0', uhd_usrp_sink_0, '0']
- [OTA_FL_read_gold_seq_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [OTA_FL_read_gold_seq_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_message_strobe_0, strobe, OTA_FL_Precoder_0, trigger]
- [blocks_message_strobe_0_0, strobe, OTA_FL_Precoder_0_0, trigger]
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_stream_mux_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_stream_mux_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', virtual_sink_0_0_0, '0']
- [blocks_repeat_0_0_0_1, '0', blocks_stream_mux_1, '1']
- [blocks_repeat_0_0_0_1_0, '0', blocks_stream_mux_1, '4']
- [blocks_repeat_0_0_0_1_0_0, '0', blocks_stream_mux_1_0, '4']
- [blocks_repeat_0_0_0_1_1, '0', blocks_stream_mux_1_0, '1']
- [blocks_stream_mux_1, '0', OTA_FL_dynamic_padder_0, '0']
- [blocks_stream_mux_1, '0', OTA_FL_dynamic_padder_py_0, '0']
- [blocks_stream_mux_1, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_mux_1, '0', uhd_usrp_sink_0, '1']
- [blocks_stream_mux_1_0, '0', uhd_usrp_sink_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', OTA_FL_Precoder_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', OTA_FL_Precoder_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_stream_mux_1, '2']
- [virtual_source_0_0_0_0, '0', blocks_stream_mux_1, '3']
- [virtual_source_0_0_0_0_0, '0', blocks_stream_mux_1_0, '3']
- [virtual_source_0_0_0_1, '0', blocks_stream_mux_1_0, '2']
- [zero_padding_0_0_0, '0', blocks_repeat_0_0_0_1, '0']
- [zero_padding_0_0_0, '0', blocks_repeat_0_0_0_1_0, '0']
- [zero_padding_0_0_0_0, '0', blocks_repeat_0_0_0_1_0_0, '0']
- [zero_padding_0_0_0_0, '0', blocks_repeat_0_0_0_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
