options:
  parameters:
    generate_options: qt_gui
    id: OFDM_Custom_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: OTA_FL_correlate_and_tag_py_0
  id: OTA_FL_correlate_and_tag_py
  parameters:
    cor_method: '0'
    feedback_type: '0'
    file_path: '"Enter folder path"'
    frame_len: 16456 + 500 + (256 * 103)
    num_Tx: '1'
    seq_len: '16456'
  states: {}
- name: OTA_FL_filter_payload_py_0
  id: OTA_FL_filter_payload_py
  parameters:
    tag_name: '"payload"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'True'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: IQ
    name: XCor
    size: '200000'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 400e3
    center_freq0: uhd.tune_request(5.3e9,1e6)
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: '"addr=10.10.23.8"'
    dev_args: '""'
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}

connections:
- [OTA_FL_correlate_and_tag_py_0, '0', OTA_FL_filter_payload_py_0, '0']
- [OTA_FL_correlate_and_tag_py_0, '1', blocks_complex_to_mag_0, '0']
- [OTA_FL_filter_payload_py_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', OTA_FL_correlate_and_tag_py_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_1_1_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', OTA_FL_correlate_and_tag_py_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
